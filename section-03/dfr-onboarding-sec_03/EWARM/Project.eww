<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\dfr-onboarding-sec_03.ewp</path>
  </project>
  <batchBuild />
</workspace>
